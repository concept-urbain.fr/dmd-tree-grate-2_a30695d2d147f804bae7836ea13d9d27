Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Demi-grille DMD 100x100.IFC
Time: 2020-05-29T08:10:18
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: Demi-grille DMD 100x100
In: Default Storey
Material: S 235
